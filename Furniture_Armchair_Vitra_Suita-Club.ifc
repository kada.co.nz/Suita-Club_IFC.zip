Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-19T15:55:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 19 15:55:53 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{84554CBC-2D8F-4DA2-90AC-869A4453C05C}\ifc * Database version: 5507 * Database creation date: Thu Sep 19 15:55:52 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 19 15:55:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 19 15:55:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Suita Club Armchair, Furniture_Armchair_Vitra_Suita-Club:Suita Club Armchair:391782
In: Level 1
Type - Material: Aluminium polished 03, Leather standard dimgrey 21
Type - Dimensions(Type) - NominalDepth: 731.902 mm; NominalHeight: 697.89 mm; NominalLength: 750 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Armchair_Vitra_Suita-Club; ConvergoRefNr: 0089-1909-0022-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Suita Club Armchair by Antonio Citterio can be combined with any member of the Suita sofa family. Thanks to its elegantly understated design, the armchair can be used on its own or paired with many other sofas. It is generously upholstered, ensuring excellent comfort even without additional cushions.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 18/09/2019
Type - Identity Data(Type) - Collection: Suita Club; Cost: 0; Description: The Suita Club Armchair by Antonio Citterio can be combined with any member of the Suita sofa family. Thanks to its elegantly understated design, the armchair can be used on its own or paired with many other sofas. It is generously upholstered, ensuring excellent comfort even without additional cushions.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: Suita Club Armchair; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-us/_storage/asset/376133/storage/master/download/Factbook%20Suita2019-EN.pdf; Type Name: Suita Club Armchair; URL: https://www.vitra.com/en-us/living/product/details/suita-club-armchair
Type - Materials and Finishes(Type) - ArmchairMainMaterial: Leather standard dimgrey 21; ArmchairSecondaryMaterial: Aluminium polished 03
Type - Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Armchair_Vitra_Suita-Club; Features: Legs: die-cast aluminium, polished or powder-coated. Body: webbed metal frame with moulded polyurethane foam.; Finish: n/a; Grade: n/a; Material: Aluminium, polyurethane & leather; ModelNumber: n/a; ModelReference: 21033300; Name: Vitra_Suita-Club; ReplacementCost: n/a; Shape: Sculptured; Size: 750x730x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 21033300; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.58313 m2; Volume: 0.38309 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Armchair_Vitra_Suita-Club: Suita Club Armchair; Family and Type: Furniture_Armchair_Vitra_Suita-Club: Suita Club Armchair; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Armchair_Vitra_Suita-Club: Suita Club Armchair; Type Id: Furniture_Armchair_Vitra_Suita-Club: Suita Club Armchair; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
